# Keil uVision project SmartHumigadget.uvproj, settings and files
target nRF51822AA (ARM-ADS)
  device: Cortex-M0+ ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: SmartHumigadget +hex
  c flags: Optim=1
  c define: TARGET_NRF51822,  TARGET_M0,  TARGET_NORDIC,  TARGET_NRF51822_MKIT,  TARGET_MCU_NRF51822,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M0,  ARM_MATH_CM0,  MBED_BUILD_TIMESTAMP=1412256918.9,  __MBED__=1,  __ASSERT_MSG,
  c misc: --gnu
  c include: .;nRF51822;nRF51822/common;nRF51822/nordic;nRF51822/nordic/app_common;nRF51822/nordic/nrf-sdk;nRF51822/nordic/nrf-sdk/app_common;nRF51822/nordic/nrf-sdk/s110;nRF51822/nordic/nrf-sdk/ble;nRF51822/nordic/nrf-sdk/ble/device_manager;nRF51822/nordic/nrf-sdk/ble/ble_services;nRF51822/nordic/nrf-sdk/bootloader_dfu;nRF51822/nordic/nrf-sdk/sd_common;nRF51822/nordic/ble;nRF51822/nordic/ble/ble_services;nRF51822/nordic/bootloader_dfu;nRF51822/btle;nRF51822/btle/custom;BLE_API;BLE_API/common;source/services;BLE_API/public;mbed;mbed/TARGET_NRF51822;mbed/TARGET_NRF51822/TARGET_NORDIC;mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822;mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/TARGET_NRF51822_MKIT;mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib;mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s110_nrf51822_7_0_0;mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s110_nrf51822_7_0_0/s110_nrf51822_7.0.0_API;mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s110_nrf51822_7_0_0/s110_nrf51822_7.0.0_API/include;mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nrf-sdk;mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nrf-sdk/app_common;mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nrf-sdk/sd_common;mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD;source
  scatter file: mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/nRF51822.sct
  link misc: mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/board.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/system_nrf51822.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/mbed.ar
            
mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/startup_nRF51822.o
  group src
    ./source/: main.cpp Sht31.cpp Sht31.h ShtLcd.cpp ShtLcd.h SmartGadget.cpp SmartGadget.h DewPoint.cpp DewPoint.h SmartGadgetPeripheral.cpp SmartGadgetPeripheral.h ServiceDataHandler.cpp ServiceDataHandler.h I2c.cpp I2c.h Logger.cpp Logger.h RingBuffer.cpp RingBuffer.h FlashCmdQueue.cpp FlashCmdQueue.h Spi.cpp Spi.h
  group nRF51822
    nRF51822/nordic/app_common/: crc16.cpp app_scheduler.c app_gpiote.c hci_mem_pool.c pstorage.cpp
    nRF51822/nordic/ble/: ble_error_log.cpp ble_advdata.cpp ble_bondmngr.cpp ble_advdata_parser.cpp ble_conn_params.cpp ble_debug_assert_handler.cpp
    nRF51822/nordic/bootloader_dfu/: bootloader_util_arm.c dfu_app_handler.c
    nRF51822/nordic/ble/ble_services/: ble_srv_common.cpp
    nRF51822/nordic/: softdevice_handler.cpp
    nRF51822/btle/: btle_gap.cpp btle_advertising.cpp btle.cpp
    nRF51822/btle/custom/: custom_helper.cpp
    nRF51822/: nRF51822n.cpp nRF51Gap.cpp nRF51GattServer.cpp
  group BLE_API
    BLE_API/common/: UUID.cpp GapAdvertisingParams.cpp GapAdvertisingData.cpp BLEDevice.cpp GattService.cpp
  group BLE_SERVICES
    ./source/services/: BatteryService.h DeviceInformationService.h HumidityService.h HumidityService.cpp TemperatureService.h TemperatureService.cpp LoggerService.cpp LoggerService.h ISensorValueServiceLogger.h
